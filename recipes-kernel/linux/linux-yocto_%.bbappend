FILESEXTRAPATHS:prepend := "${THISDIR}:"
SRC_URI += "file://0001-add-fake-device.patch"
